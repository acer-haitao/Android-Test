# Keil uVision project MagneticDetector.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1112FDH20/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MagneticDetector +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s gpio.c timer32.c uart.c WiFi.c Main.cpp system_LPC11xx.c timer16.c
